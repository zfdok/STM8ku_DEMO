# IAR project STM8ku_DEMO.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S208MB STM8S208MB
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\lib\inc; ..\lib\src; ..\lib; ..\usr; ..\bsp; ..\iar
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8ku_DEMO.hex
  ILINK.IlinkOutputFile: STM8ku_DEMO.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group BSP
    ../BSP/: led.c
  group LIB
    ../LIB/: stm8s_conf.h
  group USR
    ../USR/: main.c pbdata.c pbdata.h stm8s_it.c
